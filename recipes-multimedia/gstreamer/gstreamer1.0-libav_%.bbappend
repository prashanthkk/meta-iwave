PACKAGECONFIG_mx8qm = "gstreamer1.0-libav"
LICENSE_FLAGS_WHITELIST = "commercial"
